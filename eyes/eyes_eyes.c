/*--------------------------------------------------------------------------------------*/
/*                                                                                      */
/*  File:       eyes_eyes.c        	                                                    */
/*                                                                                      */
/*  Contains:   The routine cmd_Eyes().                                                 */
/*                                                                                      */
/*  Written by: Norman Jaffe                                                            */
/*                                                                                      */
/*  Copyright:  (c) 2001 by T. H. Schiphorst, N. Jaffe, K. Gregory and G. I. Gregson.   */
/*                                                                                      */
/*              All rights reserved. Redistribution and use in source and binary forms, */
/*              with or without modification, are permitted provided that the following */
/*              conditions are met:                                                     */
/*                * Redistributions of source code must retain the above copyright      */
/*                  notice, this list of conditions and the following disclaimer.       */
/*                * Redistributions in binary form must reproduce the above copyright   */
/*                  notice, this list of conditions and the following disclaimer in the */
/*                  documentation and/or other materials provided with the              */
/*                  distribution.                                                       */
/*                * Neither the name of the copyright holders nor the names of its      */
/*                  contributors may be used to endorse or promote products derived     */
/*                  from this software without specific prior written permission.       */
/*                                                                                      */
/*              THIS SOFTWARE IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS     */
/*              "AS IS" AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT       */
/*              LIMITED TO, THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A */
/*              PARTICULAR PURPOSE ARE DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT      */
/*              OWNER OR CONTRIBUTORS BE LIABLE FOR ANY DIRECT, INDIRECT, INCIDENTAL,   */
/*              SPECIAL, EXEMPLARY, OR CONSEQUENTIAL DAMAGES (INCLUDING, BUT NOT        */
/*              LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR SERVICES; LOSS OF USE,   */
/*              DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER CAUSED AND ON ANY   */
/*              THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY, OR TORT     */
/*              (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE   */
/*              OF THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.    */
/*                                                                                      */
/*  Created:    2001/08/23                                                              */
/*                                                                                      */
/*--------------------------------------------------------------------------------------*/

#include "eyes.h"

/*------------------------------------ cmd_Eyes ---*/
Pvoid cmd_Eyes
  (EyePtr  xx,
   PSymbol message,
   short   argc,
   PAtom   argv)
{
#if __powerc
 #pragma unused(message)
#else /* not __powerc */
 #pragma unused(message, argc, argv)
#endif /* not __powerc */
  EnterCallback();
  if (xx)
  {
#if __powerc
    EyeDescriptorPtr descriptor = xx->fActiveEye;

    if (descriptor)
    {
      if (argc)
      {
        if (argv[0].a_type == A_SYM)
        {
          PSymbol which = argv[0].a_w.w_sym;

          if (which == gReloadSymbol)
          {
            refreshDescriptors(xx);
            LOG_POST_1(OUTPUT_PREFIX "�y� reloaded")
          }
          else if (which == gListSymbol)
          {
            descriptor = gEyeAnchor;

            LOG_POST_1(OUTPUT_PREFIX "List of �y�s:")
            while (descriptor)
            {
              LOG_POST_2("  Name: %s", descriptor->fName->s_name)
              descriptor = descriptor->fNext;
            }
          }
          else if (which == gRescanSymbol)
          {
            rescanEyes();
            LOG_POST_1(OUTPUT_PREFIX "�y�s rescanned")
          }
          else
            LOG_ERROR_2(OUTPUT_PREFIX "unknown modifier '%s' for �y� command", which->s_name)
        }
        else
          LOG_ERROR_1(OUTPUT_PREFIX "unexpected modifier for �y� command")
      }
      else
        LOG_POST_4("Name: %s, inlets: %hd, outlets: %hd", descriptor->fName->s_name,
                    xx->fNumInlets, xx->fNumOutlets)
    }
#endif /* __powerc */
  }
  ExitMaxMessageHandler()
} /* cmd_Eyes */
